# Missing inherit packagegroup - should trigger MANDATORY004
SUMMARY = "Bad packagegroup without inherit"
LICENSE = "CLOSED"

RDEPENDS:${PN} = "\
    bash \
"
